# Keil uVision project led_blinky.uvprojx, settings and files
target led_blinky debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKE04Z8VFK4 NXP
  pack: NXP.MKE04Z4_DFP.10.0.2
  cpu: CPUTYPE("Cortex-M0+")
  output: led_blinky.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKE04Z8VFK4, FRDM_KE04Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../..;..
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x400
  scatter file: MKE04Z8xxx4_flash.scf
  group source
    ../: led_blinky.c
  group doc
    ../: readme.txt
target led_blinky release (ARM-ADS)
  device: MKE04Z8VFK4 NXP
  pack: NXP.MKE04Z4_DFP.10.0.2
  cpu: CPUTYPE("Cortex-M0+")
  output: led_blinky.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKE04Z8VFK4, FRDM_KE04Z, FREEDOM
  c misc: as above
  c include: ../../..;..
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x400
  scatter file: MKE04Z8xxx4_flash.scf
software components: CMSIS:CORE 5.0.1, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:gpio 2.0.0, Device:SDK Drivers:port 2.0.1, Device:SDK Drivers:uart 2.1.5, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:Startup 1.0.0
